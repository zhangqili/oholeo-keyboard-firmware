# Keil uVision project oholeo-keyboard-firmware.uvprojx, settings and files
target oholeo-keyboard-firmware (6240000::V6.24::ARMCLANG)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: oholeo-keyboard-firmware +hex
  BeforeMake: D:\git\oholeo-keyboard-firmware\MDK-ARM\mqjs_header_generator.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F303xC,LFS_NO_ASSERT,LFS_NO_DEBUG,LFS_NO_ERROR,LFS_NO_WARN,USE_FULL_LL_DRIVER,CMSIS_device_header=\"stm32f3xx.h\"
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;../libamp/src/;../libamp/src/midi/;../libamp/src/midi/bytequeue;../libamp/lib/littlefs/;../libamp/usb/;../libamp/lib/lufa;../libamp_user/;../sfud/inc/;../usb/;../CherryUSB/core;../CherryUSB/common;../CherryUSB/class/hid;../CherryUSB/port/fsdev;../snake;../ws2812;../libamp/src/lamp_array;..\libamp\src\mquickjs;..\libamp\lib\mquickjs;..\MDK-ARM;..\libamp\usb\template\cherryusb;..\libamp\src\log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group sfud
    ../sfud/port/: sfud_port.c
    ../sfud/src/: sfud.c sfud_sfdp.c
  group CherryUSB
    ../CherryUSB/core/: usbd_core.c
    ../CherryUSB/class/hid/: usbd_hid.c
    ../CherryUSB/port/fsdev/: usb_dc_fsdev.c
  group usb
    ../libamp/usb/template/cherryusb/: usbd_user.c
  group snake
    ../snake/: snake.c
  group libamp/src
    ../libamp/src/: advanced_key.c analog.c color.c dynamic_key.c extra_key.c filter.c joystick.c key.c keyboard.c layer.c mouse.c record.c rgb.c storage.c driver.c encoder.c macro.c packet.c event_buffer.c script.c large_packet.c event_cache.c file_stream.c nexus.c
  group libamp/src/midi
    ../libamp/src/midi/: midi.c midi_device.c process_midi.c qmk_midi.c sysex_tools.c
    ../libamp/src/midi/bytequeue/: bytequeue.c interrupt_setting.c
  group libamp/lib/littlefs
    ../libamp/lib/littlefs/: lfs.c lfs_util.c
  group libamp/lib/mquickjs
    ../libamp/lib/mquickjs/: cutils.c dtoa.c libm.c mquickjs.c
  group libamp_user
    ../libamp_user/: keyboard_user.c
  group ws2812
    ../ws2812/: ws2812.c
  group libamp/src/lamp_array
    ../libamp/src/lamp_array/: lamp_array.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_ll_usb.c stm32f3xx_ll_gpio.c stm32f3xx_ll_adc.c stm32f3xx_ll_dma.c stm32f3xx_ll_rcc.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group libamp/liblog
    ../libamp/src/log/: log.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:ITM 1.1.0, CMSIS:CORE 6.1.1
